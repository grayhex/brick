#include "brick/font.h"

#include <string.h>

/* 3x5 glyphs; each is written as five rows of three characters, '#' = ink. */
#define G(c, r0, r1, r2, r3, r4)                                                                                            \
    {                                                                                                                       \
        c,                                                                                                                  \
        {                                                                                                                   \
            r0, r1, r2, r3, r4                                                                                              \
        }                                                                                                                   \
    }

typedef struct {
    char c;
    const char *rows[5];
} glyph_t;

// clang-format off
static const glyph_t GLYPHS[] = {
    G('0', "###", "#.#", "#.#", "#.#", "###"),
    G('1', ".#.", "##.", ".#.", ".#.", "###"),
    G('2', "##.", "..#", ".#.", "#..", "###"),
    G('3', "##.", "..#", ".#.", "..#", "##."),
    G('4', "#.#", "#.#", "###", "..#", "..#"),
    G('5', "###", "#..", "##.", "..#", "##."),
    G('6', ".##", "#..", "###", "#.#", "###"),
    G('7', "###", "..#", ".#.", ".#.", ".#."),
    G('8', "###", "#.#", "###", "#.#", "###"),
    G('9', "###", "#.#", "###", "..#", "##."),
    G('A', ".#.", "#.#", "###", "#.#", "#.#"),
    G('B', "##.", "#.#", "##.", "#.#", "##."),
    G('C', ".##", "#..", "#..", "#..", ".##"),
    G('D', "##.", "#.#", "#.#", "#.#", "##."),
    G('E', "###", "#..", "##.", "#..", "###"),
    G('F', "###", "#..", "##.", "#..", "#.."),
    G('G', ".##", "#..", "#.#", "#.#", ".##"),
    G('H', "#.#", "#.#", "###", "#.#", "#.#"),
    G('I', "###", ".#.", ".#.", ".#.", "###"),
    G('J', "..#", "..#", "..#", "#.#", ".#."),
    G('K', "#.#", "#.#", "##.", "#.#", "#.#"),
    G('L', "#..", "#..", "#..", "#..", "###"),
    G('M', "#.#", "###", "###", "#.#", "#.#"),
    G('N', "##.", "#.#", "#.#", "#.#", "#.#"),
    G('O', ".#.", "#.#", "#.#", "#.#", ".#."),
    G('P', "##.", "#.#", "##.", "#..", "#.."),
    G('Q', ".#.", "#.#", "#.#", "##.", ".##"),
    G('R', "##.", "#.#", "##.", "#.#", "#.#"),
    G('S', ".##", "#..", ".#.", "..#", "##."),
    G('T', "###", ".#.", ".#.", ".#.", ".#."),
    G('U', "#.#", "#.#", "#.#", "#.#", "###"),
    G('V', "#.#", "#.#", "#.#", "#.#", ".#."),
    G('W', "#.#", "#.#", "###", "###", "#.#"),
    G('X', "#.#", "#.#", ".#.", "#.#", "#.#"),
    G('Y', "#.#", "#.#", ".#.", ".#.", ".#."),
    G('Z', "###", "..#", ".#.", "#..", "###"),
    G('-', "...", "...", "###", "...", "..."),
    G('.', "...", "...", "...", "...", ".#."),
    G(':', "...", ".#.", "...", ".#.", "..."),
    G('>', "#..", ".#.", "..#", ".#.", "#.."),
    G('<', "..#", ".#.", "#..", ".#.", "..#"),
    G('/', "..#", "..#", ".#.", "#..", "#.."),
    G('+', "...", ".#.", "###", ".#.", "..."),
    G('!', ".#.", ".#.", ".#.", "...", ".#."),
    G('?', "##.", "..#", ".#.", "...", ".#."),
    G('=', "...", "###", "...", "###", "..."),
    G(' ', "...", "...", "...", "...", "..."),
};
// clang-format on

static const glyph_t *find_glyph(char c)
{
    if (c >= 'a' && c <= 'z') {
        c = (char)(c - 'a' + 'A');
    }
    for (size_t i = 0; i < sizeof GLYPHS / sizeof GLYPHS[0]; i++) {
        if (GLYPHS[i].c == c) {
            return &GLYPHS[i];
        }
    }
    return NULL;
}

bool bk_font_glyph(char c, uint8_t rows[BK_GLYPH_H])
{
    const glyph_t *g = find_glyph(c);
    if (g == NULL) {
        memset(rows, 0, BK_GLYPH_H);
        return false;
    }
    for (int r = 0; r < BK_GLYPH_H; r++) {
        uint8_t v = 0;
        for (int x = 0; x < BK_GLYPH_W; x++) {
            v = (uint8_t)((v << 1) | (g->rows[r][x] == '#' ? 1u : 0u));
        }
        rows[r] = v;
    }
    return true;
}

int bk_text_width(const char *s, int scale)
{
    int n = (int)strlen(s);
    return n == 0 ? 0 : n * bk_text_pitch(scale) - scale;
}

int bk_text_height(int scale)
{
    return BK_GLYPH_H * scale;
}

void bk_text_draw(bk_frame_t *f, int x, int y, int scale, const char *s)
{
    for (; *s != '\0'; s++, x += bk_text_pitch(scale)) {
        uint8_t rows[BK_GLYPH_H];
        if (!bk_font_glyph(*s, rows)) {
            continue;
        }
        for (int r = 0; r < BK_GLYPH_H; r++) {
            for (int c = 0; c < BK_GLYPH_W; c++) {
                if (rows[r] & (1u << (BK_GLYPH_W - 1 - c))) {
                    bk_frame_fill_rect(f, x + c * scale, y + r * scale, scale, scale, true);
                }
            }
        }
    }
}

/* ---------------------------------------------------------------- menu sprites */

/* Big 4x7 digits: the "2" is from a photo of the original screen, the rest follow its style (reference menuArt.ts). */
// clang-format off
static const char *const BIG_DIGITS[10][BK_BIG_H] = {
    {".##.", "#..#", "#..#", "#..#", "#..#", "#..#", ".##."},
    {"..#.", ".##.", "..#.", "..#.", "..#.", "..#.", ".###"},
    {".##.", "#..#", "#..#", "..#.", ".#..", "#...", "####"},
    {"###.", "...#", "...#", ".##.", "...#", "...#", "###."},
    {"...#", "..##", ".#.#", "#..#", "####", "...#", "...#"},
    {"####", "#...", "###.", "...#", "...#", "#..#", ".##."},
    {".##.", "#...", "#...", "###.", "#..#", "#..#", ".##."},
    {"####", "...#", "..#.", ".#..", ".#..", ".#..", ".#.."},
    {".##.", "#..#", "#..#", ".##.", "#..#", "#..#", ".##."},
    {".##.", "#..#", "#..#", ".###", "...#", "...#", ".##."},
};
// clang-format on

// clang-format off
static const char *const BIG_LETTERS[26][BK_BIG_H] = {
    {".##.", "#..#", "#..#", "####", "#..#", "#..#", "#..#"}, /* A */
    {"###.", "#..#", "#..#", "###.", "#..#", "#..#", "###."}, /* B */
    {".##.", "#..#", "#...", "#...", "#...", "#..#", ".##."}, /* C */
    {"###.", "#..#", "#..#", "#..#", "#..#", "#..#", "###."}, /* D */
    {"####", "#...", "#...", "###.", "#...", "#...", "####"}, /* E */
    {"####", "#...", "#...", "###.", "#...", "#...", "#..."}, /* F */
    {".##.", "#..#", "#...", "#.##", "#..#", "#..#", ".###"}, /* G */
    {"#..#", "#..#", "#..#", "####", "#..#", "#..#", "#..#"}, /* H */
    {"###.", ".#..", ".#..", ".#..", ".#..", ".#..", "###."}, /* I */
    {"..##", "...#", "...#", "...#", "#..#", "#..#", ".##."}, /* J */
    {"#..#", "#.#.", "##..", "#...", "##..", "#.#.", "#..#"}, /* K */
    {"#...", "#...", "#...", "#...", "#...", "#...", "####"}, /* L */
    {"#..#", "####", "####", "#..#", "#..#", "#..#", "#..#"}, /* M */
    {"#..#", "##.#", "##.#", "#.##", "#.##", "#..#", "#..#"}, /* N */
    {".##.", "#..#", "#..#", "#..#", "#..#", "#..#", ".##."}, /* O */
    {"###.", "#..#", "#..#", "###.", "#...", "#...", "#..."}, /* P */
    {".##.", "#..#", "#..#", "#..#", "#.##", "#..#", ".###"}, /* Q */
    {"###.", "#..#", "#..#", "###.", "##..", "#.#.", "#..#"}, /* R */
    {".###", "#...", "#...", ".##.", "...#", "...#", "###."}, /* S */
    {"###.", ".#..", ".#..", ".#..", ".#..", ".#..", ".#.."}, /* T */
    {"#..#", "#..#", "#..#", "#..#", "#..#", "#..#", ".##."}, /* U */
    {"#..#", "#..#", "#..#", "#..#", "#..#", ".##.", ".##."}, /* V */
    {"#..#", "#..#", "#..#", "#..#", "####", "####", "#..#"}, /* W */
    {"#..#", "#..#", ".##.", ".##.", ".##.", "#..#", "#..#"}, /* X */
    {"#.#.", "#.#.", "#.#.", ".#..", ".#..", ".#..", ".#.."}, /* Y */
    {"####", "...#", "..#.", ".#..", "#...", "#...", "####"}, /* Z */
};
// clang-format on

/* Small 3x5 digits for the mode number; "1" is a single bar at the right edge, as on the original (reference). */
// clang-format off
static const char *const SMALL_DIGITS[10][BK_GLYPH_H] = {
    {"###", "#.#", "#.#", "#.#", "###"},
    {"..#", "..#", "..#", "..#", "..#"},
    {"###", "..#", "###", "#..", "###"},
    {"###", "..#", "###", "..#", "###"},
    {"#.#", "#.#", "###", "..#", "..#"},
    {"###", "#..", "###", "..#", "###"},
    {"###", "#..", "###", "#.#", "###"},
    {"###", "..#", "..#", "..#", "..#"},
    {"###", "#.#", "###", "#.#", "###"},
    {"###", "#.#", "###", "..#", "###"},
};
// clang-format on

const char *const *bk_big_glyph(char c)
{
    if (c >= '0' && c <= '9') {
        return BIG_DIGITS[c - '0'];
    }
    if (c >= 'a' && c <= 'z') {
        c = (char)(c - 'a' + 'A');
    }
    if (c >= 'A' && c <= 'Z') {
        return BIG_LETTERS[c - 'A'];
    }
    return NULL;
}

const char *const *bk_small_digit(int d)
{
    return (d >= 0 && d <= 9) ? SMALL_DIGITS[d] : NULL;
}
